# Keil uVision project CARD_WRITER_usb485_232.uvproj, settings and files
target Target 1 (MCS-51)
  device: M6032 Acer Labs
  cpu: IRAM(0-0xFF) CLOCK(33000000) XRAM (0-0xFF) MODDP2
  output: CARD_WRITER_usb485_232 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: CARD_WRITER_usb485_232.c STC_INIT.C STC_ISR.C STC_USER.C
